Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-06-23T19:48:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 23 19:48:37 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\a8b81a45-bc04-4638-93d5-d3fb21c8155a\cb4f7d55-7d8c-49d5-9b86-bb31da68d635\ifc * Database version: 5507 * Database creation date: Fri Jun 23 19:48:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 23 19:48:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 23 19:48:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1011FZ Washbasin faucet, 3 V, Bluetooth, 1011FZ(2023):1011FZ Washbasin faucet, 3 V, Bluetooth:76253
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 152.153 mm; FaucetNominalHeight: 166.784 mm; FaucetNominalWidth: 50.1115 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 316.9 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2; Bluetooth: 5.x (D060576); Electrical Connection: 9 V; Operating Voltage: 39 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 1011FZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150101946; EMC Directive: 2014/53/EU , 2011/65/EU; EN Standard: EN 817, EN 15091; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110458; Noise Class: I (ISO 3822); NRF Number: 4200598; RSK Number: 8430069; Sales Package dimensions (LxWxH): 590 x 180 x 63; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1011FZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/182712_1011FZ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1011FZ; URL WEEE: http://static.oras.com/WEEE/1011FZ; VVS Number: 704246504
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1011FZ; 3D View: https://static.oras.com/AR/1011FZ; Catalog Drawing URL: http://static.oras.com/catdrw/1011FZ; Dimension Drawing URL: http://static.oras.com/dimdrw/1011FZ; FDV Document URL: http://www.oras.com/datasheet/1011FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1011FZ; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1011FZ; Interactive AR View URL: https://static.oras.com/AR/1011FZ; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1011FZ; Model: 1011FZ Washbasin faucet, 3 V, Bluetooth; Name_en: 1011FZ Washbasin faucet, 3 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1011FZ; Product Family: Oras Safira Hybrid; Product Image URL: http://static.oras.com/image/1011FZ; Product URL: http://static.oras.com/1011FZ; Technical DataSheet URL: http://www.oras.com/datasheet/1011FZ/en; Type Name: 1011FZ Washbasin faucet, 3 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Standard aerator; Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Backflow Prevention EN1717: EB; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: ;Solenoid valve;Low battery indicator; Flow Rate At 300kPa: 0.00317832 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 10 s(1 - 1800 s); Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 300000 Pa; Shower Spray Number: 1 shower spray; Spout Projection: 115 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1011FZ(2023); Features: Single-lever;Hybrid;Battery-operated;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1011FZ; Name: 1011FZ Washbasin faucet, 3 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 50x155x170 mm / Hand shower: 60x70x320 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0860986 m2; Volume: 0.00251089 m3
Identity Data - Mark: 30
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1011FZ(2023): 1011FZ Washbasin faucet, 3 V, Bluetooth; Family and Type: 1011FZ(2023): 1011FZ Washbasin faucet, 3 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1011FZ(2023): 1011FZ Washbasin faucet, 3 V, Bluetooth; Type Id: 1011FZ(2023): 1011FZ Washbasin faucet, 3 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
